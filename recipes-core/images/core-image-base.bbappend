IMAGE_INSTALL += " bbmessage-traits-lt"
